SUMMARY = "Kestro toolchain"
DESCRIPTION = "Recipe for building the Kestro toolchain"
LICENSE = "CLOSED"

inherit populate_sdk populate_sdk_kestro
