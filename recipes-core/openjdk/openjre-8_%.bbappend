RPROVIDES_${PN} = "virtual/java"