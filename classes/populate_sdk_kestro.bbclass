inherit populate_sdk_qt5

TOOLCHAIN_TARGET_TASK += "packagegroup-kestro-toolchain-target"

